# Keil uVision project project.uvprojx, settings and files
target STM32F407 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: output1 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,USE_USB_OTG_HS,USE_EMBEDDED_PHY
  c misc: --diag_suppress=870
  c include: ..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\Libraries\CMSIS\Include;..\..\Libraries\STM32_USB_HOST_Library\Class\MSC\inc;..\..\Libraries\STM32_USB_HOST_Library\Core\inc;..\..\Libraries\STM32_USB_OTG_Driver\inc;..\..\User;..\..\User\bsp_stm32f4xx;..\..\User\bsp_stm32f4xx\inc;..\..\User\FatFS\src;..\..\User\usbh_mass_storage;..\..\SYSTEM;..\..\SYSTEM\http;..\..\SYSTEM\LAN8742A;..\..\SYSTEM\lwip-1.4.1\port\arch;..\..\SYSTEM\lwip-1.4.1\port\Standalone;..\..\SYSTEM\lwip-1.4.1\src\include\lwip;..\..\SYSTEM\lwip-1.4.1\src\include\ipv4;..\..\SYSTEM\lwip-1.4.1\src\include\netif;..\..\SYSTEM\lwip-1.4.1\src\include;..\..\SYSTEM\lwip-1.4.1\port
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../../User/: main.c demo_fatfs.c main.h
  group BSP
    ../../User/bsp_stm32f4xx/src/: bsp_timer.c bsp_uart_fifo.c
    ../../User/bsp_stm32f4xx/: stm32f4xx_it.c stm32f4xx_assert.c bsp.c
  group MDK-ARM
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f4xx.s
  group StdPeriph_Driver
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_rcc.c stm32f4xx_syscfg.c misc.c stm32f4xx_gpio.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_dma.c stm32f4xx_adc.c stm32f4xx_flash.c
  group CMSIS
    ../../User/bsp_stm32f4xx/: system_stm32f4xx.c
  group FatFS
    ../../User/FatFS/src/: ff.c diskio.c diskio.h
    ../../User/FatFS/src/option/: cc936.c
  group USB Host Driver
    ../../Libraries/STM32_USB_HOST_Library/Class/MSC/src/: usbh_msc_bot.c usbh_msc_core.c usbh_msc_scsi.c
    ../../Libraries/STM32_USB_HOST_Library/Core/src/: usbh_core.c usbh_hcs.c usbh_ioreq.c usbh_stdreq.c
    ../../Libraries/STM32_USB_OTG_Driver/src/: usb_hcd_int.c usb_core.c usb_hcd.c
  group USBH Masss Storage
    ../../User/usbh_mass_storage/: usbh_usr.c usb_bsp.c usbh_bsp_msc.h usbh_it.c
  group SYSTEM
    ../../SYSTEM/: CRC.c CRC.h delay.c delay.h DMA.c DMA.h HONG.c HONG.h sys.c sys.h USART.c USART.h RS232.c RS232.h led.c led.h timer.c timer.h pwm.c pwm.h DMAPWM.c DMAPWM.h
  group http
    ../../SYSTEM/LAN8742A/: LAN8742A.c LAN8742A.h stm32f429_eth.c stm32f429_eth.h stm32f429_eth_conf.h
    ../../SYSTEM/http/: fs.c fs.h http_client.c http_client.h httpd.c httpd.h httpd_cgi_ssi.c httpd_structs.h netconf.c netconf.h ota_update.c ota_update.h
  group Iwip
    ../../SYSTEM/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../SYSTEM/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../../SYSTEM/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    ../../SYSTEM/lwip-1.4.1/src/netif/: etharp.c
    ../../SYSTEM/lwip-1.4.1/port/Standalone/: ethernetif.c
target CpuRAM (ARM-ADS)
  device: STM32F407VE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: as above
  output: output +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F4XX,USE_USB_OTG_HS,USE_EMBEDDED_PHY,VECT_TAB_SRAM
  c misc: --diag_suppress=870
  c include: ..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\Libraries\CMSIS\Include;..\..\Libraries\STM32_USB_HOST_Library\Class\MSC\inc;..\..\Libraries\STM32_USB_HOST_Library\Core\inc;..\..\Libraries\STM32_USB_OTG_Driver\inc;..\..\User;..\..\User\bsp_stm32f4xx;..\..\User\bsp_stm32f4xx\inc;..\..\User\FatFS\src;..\..\User\usbh_mass_storage
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
